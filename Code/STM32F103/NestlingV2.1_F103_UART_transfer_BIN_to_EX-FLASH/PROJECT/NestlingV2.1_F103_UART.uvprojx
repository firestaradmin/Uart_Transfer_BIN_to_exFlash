# Keil uVision project NestlingV2.1_F103_UART.uvprojx, settings and files
target NestlingV2.0_CPP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NestlingV2.0_CPP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,STM32
  c misc: --cpp11
  c include: ..\Lib\FWLib\inc;..\Lib\CORE;..\USER;..\Bsp\TIM;..\Bsp\USART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.cpp stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ../Bsp/LED/: LED.c
    ../Bsp/USART/: usart.cpp
    ../Bsp/transfer_BIN_to_EX_FLASH/: transfer_BIN_to_EX_FLASH.cpp transfer_BIN_to_EX_FLASH.h
    ../Bsp/TIM/: myTIM.h myTIM.c
    ../Bsp/delay/: delay.c
    ../Bsp/W25QXX/: w25qxx.c w25qxx.h
    ../Bsp/SPI/: spi.c spi.h
  group FWLib
    ../Lib/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../Lib/CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
